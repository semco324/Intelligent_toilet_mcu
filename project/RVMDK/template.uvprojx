# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX_MD
  c include: ..\..\libraries\STM32F0_LIB\inc;..\..\libraries\CMSIS;..\..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../libraries/CMSIS/: startup_stm32f0xx.s
  group CMSIS
    ../../libraries/CMSIS/: core_cm0.h core_cmFunc.h core_cmInstr.h
  group FWLIB
    ../../libraries/STM32F0_LIB/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ../../user/: main.c stm32f0xx_it.c system_stm32f0xx.c usart.c timer.c csm37f59.c sleep.c wdt.c flash.c lib_queue.c ble_parse.c driver_csm92p10.c lib_delay.c lib_myiic.c lib_comm.c driver_cs1258.c addr_map.c CS_HRI_V112.lib CS_BIA_V433.lib analysis.c eb_parse.c lib_parse.c wifi_parse.c
  group DOC
    ../../doc/: README.txt
